# Repository oskarjohansson/Elita-electrical-system

File README.md:

# Elita power distribution
> Created by Oskar Johansson 

This project is to refine the electrical system on the sailboat *Elita*. 

## Background

> A short background of the project. 

*Elita* was bought 2019 and had a relative good electrical system, but with poorly documentation. Since one of the complex part of a boat is the electrical system, the need of a reliable and easy system is important and there exists few power distribution system that is affordable. Then practical problems like have to wire everything through a panel to switch on and off seems quite old-fashioned.  

## Goal

> The goal of the project is 

The aim for this project is to simplify the wiring and make it possible for non-electrical-engineer to troubleshoot the system, like my brothers. 

The project will also aim to make it easier to do maintenance, like having a connector to all devices to make it easy to just unplug it without having to remove any cable. 

The project will also target one of the issues of the electrical system on a boat, the wire length. Since the voltage is 12 V, the voltage drop will affect the efficiency a lot when the wires become long. Together with that you want a control panel that is easily accessible the wiring become both long and complex. 

## Directories 

> The directories of the project. 

```python
Elita-electrical-system
├── documents                 # Manuals, ISO-documents, etc.       
│   └── datasheets            # Datasheet for components.
├── hardware                  # Schematics, pcbs, etc.
│   ├── battery-protection    # >100 A voltage protection for battery 
│   ├── cad                   # All CAD files 
│   ├── control-panel         # The control panel where all power switches are
│   ├── electrical-system     # Summary of the whole system
│   ├── flyback-protection    # To use in series of DC-motors to protect electrical system from flyback-currents.
│   ├── gerber                # Common folder for all gerber-files.
│   ├── ideal-diode           # An ideal diode circuit to charge the start battery everytime the bulk batteries is more charged.
│   ├── led-dimmer            # A simple dimmer for LED strips using a rotate encoder and mosfet
│   ├── libraries             # Project specific library.
│   ├── mount-panel           # A panel to mount the power distribution boards on.
│   ├── mppt-solar-charger    # A new controller to be used instead of the PWM controller.
│   ├── power-connector       # A simple power connector with M5 connectors. 
│   ├── power-distribution    			# Distribute power through mosfets and switches.
│   ├── power-distribution-complete		# Distribute all power through mosfets and switches.
│   ├── powersplitter         # In-line to split up the power-line.
│   ├── schematic             # All electrical schematics.
│   └── shorepower            # Schematic over how the shorepower should be connected according to complient ISO.
├── img                       # Images 
└── software                  # Firmwares
    └── led_dimmer            # Fiwmare for the led dimmer. 
```

# System 

> Here will the description of the system be. 

## Requirements

> The requirements of the system. 

- Follow ISO-standard, here ISO-10133 and ISO-13297
- Easy to use
- Lowest voltage drop possible
- No heat issue
- Integrated fuse
- Power meter 
- Easy to debug 
- Input from solar panel

## System architecture

> The architecture of the system. 

```python
├── Start battery           			# Must always be top charged.   
|	^
|	|
|	Ideal diode 						# To also charge the start battery from solar panel. 
|	^
|	|
└── House battery           			# Firmwares
    └── 120 A fuse          			# A resettable fuse
        ├── Fuse holder					# For things that shouldn't be switched off, like heater.
        |   └── Heater					# The heater has a cooldown process. 
	    └── Battery protection          # To protect from UV and be able to turn on/off from far away. 
	    	├── Fuse holder				# For things that has an integrated switch, like lighting. 
            |	├── Engine				# Everything that has to do with the engine.
            	|
                |
            |   └── Internal lights		# Has a switch on it.  
	    	└── Power distribution		# A fused power distribution with switches.
            	├── Navigation lights	
                |
                |
            	└── Refigerator 		  
```

> The power distribution of the system. 

## Subsystems

> Some of the sub sytem with the power consumption. 

| Subsystem         | Power consumption | Need switch | Comment                            |
| ----------------- | ----------------- | ----------- | ---------------------------------- |
| Navigation lights | 3x15 W            | Yes         |                                    |
| Motor lights      | 1x15 W            | Yes         |                                    |
| Anchor lights     | 5 W               | Yes         | Doesn't exist yet.                 |
| Deck light        | 35 W              | Yes         |                                    |
| Cabin light       | 40 W              | Yes         | Doesn't exist yet.                 |
| Stereo            | 50 W              | Yes         |                                    |
| Water pump        | 35 W              | Yes         |                                    |
| Refigerator       | 50 W              | Yes         |                                    |
| Septi pump        | 50 W              | Yes         |                                    |
| Instrument panel  | 100 W             | Yes         | VHF, Plotter, etc.                 |
| 12V + usb outlet  | 50 W              | Yes         |                                    |
| Inverter 12/220V  | 600 W             | Yes         | Some 50 A relay maybe              |
| Current meter     |                   | No          | Hall current meter                 |
| Voltage meter     |                   | No          | Should always be on                |
| Switched light    | 5x5 W + 15 W      | No          | Bedside, toilet and kitchen        |
| Heater            | 40 W              | No          | Has is own control panel           |
| Solar panel       | 50 W              | No          | Output from controller to battery. |

# Tips from different sources

> A list of different tips and link for more information. 

- Bigger cables closes to terminal
- Accessible battery switch
- Strict color coding!

## KiCad design hardware/inline-dimmer/inline-dimmer.kicad_pcb

File hardware/README.md:

# Hardware

## Power distribution

### Schematic 

## Shore power

### Schematic 

## Flyback protection

### Schematic 

## Power splitter

### Schematic

Board: 2 copper layers, 42.0 x 13.6 mm, 17 parts (12 on the bottom side), 10 nets.

Parts:
C3: 2.2uF 16V; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
D2, D3: RB751S40T5G; D_SOD-523
D5: D_Schottky; D_SOD-123
J1, J2: Conn_01x01; MountingHole_5.5mm_Pad_Via
J3: 1984633; TerminalBlock_4Ucon_1x04_P3.50mm_Horizontal
J4, J5: 74651175R; M5_74651175R_Solder
Q2: DMP3013SFV; Diodes_PowerDI3333-8
R1: 2k; R_0603_1608Metric
R7, R8: R; R_0603_1608Metric
R9: 100k; R_0603_1608Metric
R10: 1k; R_0603_1608Metric
U1: MIC1555YM5-TR; SOT-23-5

Connections:
+12V: J1.1, J4.1, R9.2, U1.1
/GATE: R9.1, R10.1
/LED_OUT: D5.1, J2.1, J5.1, R1.1
/PWM: D2.2, D3.1, R10.2, U1.3
/TRG_THR: C3.1, J3.2, R7.2, R8.2, U1.4, U1.5
GND: C3.2, D1.1, D5.2, J3.4, U1.2
unnamed: D1.2, R1.2
unnamed: D2.1, J3.1, R7.1
unnamed: D3.2, J3.3, R8.1
unnamed: Q2.1, Q2.2, Q2.3

## KiCad design hardware/power-distribution-complete/power-distribution-complete.kicad_pcb

Parts:
J3, J4, J5, J6, J7, J8, J9, J11, J12, J13, J14, J15, J16, J17: Parallell; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16: Q_PMOS_GDS; TO-252-2-ThermalVias
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SWITCH_A1, SWITCH_A2, SWITCH_A3, SWITCH_A4: Screw_Terminal_01x0; TerminalBlock_02_P5.00mm
SWITCH_B1, SWITCH_B2, SWITCH_B3, SWITCH_B4: Screw_Terminal_01x02; TerminalBlock_02_P5.00mm
SWITCH_C1, SWITCH_C2, SWITCH_C3, SWITCH_C4, SWITCH_C5, SWITCH_C6, SWITCH_C7, SWITCH_C8: Screw_Terminal_01x02; TerminalBlock_02_P5.00mm

Connections:
+12V: Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), Q7.3 (S), Q8.3 (S), Q9.3 (S), Q10.3 (S), Q11.3 (S), Q12.3 (S), Q13.3 (S), Q14.3 (S), Q15.3 (S), Q16.3 (S), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1; also elsewhere on the board
/Switch/G1: J3.1, Q1.1 (G), R1.2, SWITCH_A1.1
GND: SWITCH_A1.2, SWITCH_A2.2, SWITCH_A3.2, SWITCH_A4.2, SWITCH_B1.2, SWITCH_B2.2, SWITCH_B3.2, SWITCH_B4.2, SWITCH_C1.2, SWITCH_C2.2, SWITCH_C3.2, SWITCH_C4.2, SWITCH_C5.2, SWITCH_C6.2, SWITCH_C7.2, SWITCH_C8.2; also elsewhere on the board
unnamed: J3.2, J4.1, Q2.1 (G), R2.2, SWITCH_B1.1
unnamed: J4.2, J5.1, Q3.1 (G), R3.2, SWITCH_C1.1
unnamed: J5.2, J6.1, Q4.1 (G), R4.2, SWITCH_C2.1
unnamed: J6.2, J9.2, Q8.1 (G), R8.2, SWITCH_C4.1
unnamed: J7.1, Q5.1 (G), R5.2, SWITCH_A2.1
unnamed: J7.2, J8.1, Q6.1 (G), R6.2, SWITCH_B2.1
unnamed: J8.2, J9.1, Q7.1 (G), R7.2, SWITCH_C3.1
unnamed: J11.1, Q9.1 (G), R9.2, SWITCH_A3.1
unnamed: J11.2, J12.1, Q10.1 (G), R10.2, SWITCH_B3.1
unnamed: J12.2, J13.1, Q11.1 (G), R11.2, SWITCH_C5.1
unnamed: J13.2, J14.1, Q12.1 (G), R12.2, SWITCH_C6.1
unnamed: J14.2, J17.2, Q16.1 (G), R16.2, SWITCH_C8.1
unnamed: J15.1, Q13.1 (G), R13.2, SWITCH_A4.1
unnamed: J15.2, J16.1, Q14.1 (G), R14.2, SWITCH_B4.1
unnamed: J16.2, J17.1, Q15.1 (G), R15.2, SWITCH_C7.1
SSR-A: Q1.2 (D); also elsewhere on the board
SSR-B: Q2.2 (D); also elsewhere on the board
SSR-C: Q3.2 (D); also elsewhere on the board
SSR-D: Q4.2 (D); also elsewhere on the board
SSR-E: Q8.2 (D); also elsewhere on the board
SSR-F: Q7.2 (D); also elsewhere on the board
SSR-G: Q6.2 (D); also elsewhere on the board
SSR-H: Q5.2 (D); also elsewhere on the board
SSR-I: Q9.2 (D); also elsewhere on the board
SSR-J: Q10.2 (D); also elsewhere on the board
SSR-K: Q11.2 (D); also elsewhere on the board
SSR-L: Q12.2 (D); also elsewhere on the board
SSR-M: Q16.2 (D); also elsewhere on the board
SSR-N: Q15.2 (D); also elsewhere on the board
SSR-O: Q14.2 (D); also elsewhere on the board
SSR-P: Q13.2 (D); also elsewhere on the board

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D17, D18, D19, D20, D21, D22, D23, D24, D33, D34, D35, D36: D_Small; SMF-DO-219AB
D9, D10, D11, D12, D13, D14, D15, D16, D25, D26, D27, D28, D29, D30, D31, D32: 2V; LED_0603_1608Metric
F1, F2, F3, F4, F5, F6, F7, F8, F9, F10, F11, F12, F13, F14, F15, F16, F17, F18, F19, F20: Fuse; ATO_Fuseholder_3522-2
J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28, J29, J30, J31, J32, J33, J34, J35, J36, J37: POUT; M5_7461383
R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: 1k; R_0603_1608Metric

Connections:
+12V: F17.2, F18.2, F19.2, F20.2; also elsewhere on the board
/Output/AOUT: D1.1 (K), D9.2 (A), F1.1, J18.1
/Output/BOUT: D2.1 (K), D10.2 (A), F2.1, J19.1
/Output/COUT: D3.1 (K), D11.2 (A), F3.1, J20.1
/Output/DOUT: D4.1 (K), D12.2 (A), F4.1, J21.1
/Output/EOUT: D5.1 (K), D13.2 (A), F5.1, J22.1
/Output/FOUT: D6.1 (K), D14.2 (A), F6.1, J23.1
/Output/GOUT: D7.1 (K), D15.2 (A), F7.1, J24.1
/Output/HOUT: D8.1 (K), D16.2 (A), F8.1, J25.1
/Output/IOUT: D24.1 (K), D32.2 (A), F16.1, J33.1
/Output/JOUT: D23.1 (K), D31.2 (A), F15.1, J32.1
/Output/KOUT: D22.1 (K), D30.2 (A), F14.1, J31.1
/Output/LOUT: D21.1 (K), D29.2 (A), F13.1, J30.1
/Output/MOUT: D20.1 (K), D28.2 (A), F12.1, J29.1
/Output/NOUT: D19.1 (K), D27.2 (A), F11.1, J28.1
/Output/OOUT: D18.1 (K), D26.2 (A), F10.1, J27.1
/Output/OUTNM1: D36.1 (K), F17.1, J34.1
/Output/OUTNM2: D35.1 (K), F18.1, J35.1
/Output/OUTNM3: D34.1 (K), F19.1, J36.1
/Output/OUTNM4: D33.1 (K), F20.1, J37.1
/Output/POUT: D17.1 (K), D25.2 (A), F9.1, J26.1
GND: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D33.2 (A), D34.2 (A), D35.2 (A), D36.2 (A), R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1; also elsewhere on the board
unnamed: D9.1 (K), R17.2
unnamed: D10.1 (K), R18.2
unnamed: D11.1 (K), R19.2
unnamed: D12.1 (K), R20.2
unnamed: D13.1 (K), R21.2
unnamed: D14.1 (K), R22.2
unnamed: D15.1 (K), R23.2
unnamed: D16.1 (K), R24.2
unnamed: D25.1 (K), R25.2
unnamed: D26.1 (K), R26.2
unnamed: D27.1 (K), R27.2
unnamed: D28.1 (K), R28.2
unnamed: D29.1 (K), R29.2
unnamed: D30.1 (K), R30.2
unnamed: D31.1 (K), R31.2
unnamed: D32.1 (K), R32.2
SSR-A: F1.2; also elsewhere on the board
SSR-B: F2.2; also elsewhere on the board
SSR-C: F3.2; also elsewhere on the board
SSR-D: F4.2; also elsewhere on the board
SSR-E: F5.2; also elsewhere on the board
SSR-F: F6.2; also elsewhere on the board
SSR-G: F7.2; also elsewhere on the board
SSR-H: F8.2; also elsewhere on the board
SSR-I: F16.2; also elsewhere on the board
SSR-J: F15.2; also elsewhere on the board
SSR-K: F14.2; also elsewhere on the board
SSR-L: F13.2; also elsewhere on the board
SSR-M: F12.2; also elsewhere on the board
SSR-N: F11.2; also elsewhere on the board
SSR-O: F10.2; also elsewhere on the board
SSR-P: F9.2; also elsewhere on the board

Notes on the sheet:
VSSAF512-M3/H
150060VS55040
https://www.mouser.se/datasheet/2/427/smf5v0atosmf58a-1767769.pdf

Parts:
D37, D38, D39: D_Small; SMF-DO-219AB
D_LED_IN1: 2V; LED_0603_1608Metric
D_LED_OUT1: 2V; LED_0603_1608Metric
J39, J40: M6 Battery input; M6_7461098
Q17, Q18, Q19, Q20, Q21, Q22: Q_NMOS_SGD; SQJA72EPT1_GE3
R_LED_IN1: 680R; R_0603_1608Metric
R_LED_OUT1: 680R; R_0603_1608Metric
SHDN_PD1: 10k; R_0603_1608Metric
SWITCH_A5: ON/OFF; TerminalBlock_02_P5.00mm
U1: LTC4365TS8; SOT-23-8
UV1: 10k; R_0603_1608Metric
UV2: 470R; R_0603_1608Metric
UV3: 100pF; C_0603_1608Metric

Connections:
12V_in: D37.1 (K), D38.1 (K), D39.1 (K), J39.1, Q17.3 (D), Q18.3 (D), Q19.3 (D), Q20.3 (D), Q21.3 (D), Q22.3 (D), R_LED_IN1.1, SWITCH_A5.1, U1.1 (Vin), UV1.1
+12V: Q17.1 (S), Q18.1 (S), Q19.1 (S), Q20.1 (S), Q21.1 (S), Q22.1 (S), R_LED_OUT1.1, U1.7 (Vout); also elsewhere on the board
GND: D37.2 (A), D38.2 (A), D39.2 (A), D_LED_IN1.1 (K), D_LED_OUT1.1 (K), J40.1, SHDN_PD1.2, U1.3 (OV), U1.4 (GND), UV2.2, UV3.2; also elsewhere on the board
unnamed: D_LED_IN1.2 (A), R_LED_IN1.2
unnamed: D_LED_OUT1.2 (A), R_LED_OUT1.2
unnamed: U1.2 (UV), UV1.2, UV2.1, UV3.1
gate_driver: Q17.2 (G), Q18.2 (G), Q19.2 (G), Q20.2 (G), Q21.2 (G), Q22.2 (G), U1.8 (GATE)
~SHDN: SHDN_PD1.1, SWITCH_A5.2, U1.5 (~SHDN)

Notes on the sheet:
Power mosfets
Battery 12V M6 input
UV Protection
Led indicator
SI7157DP-T1-GE3
0.5 V
Do not use UV
12.00 V - 434 Ohm 11.75 V - 444 Ohm 11.50 V - 454 Ohm 11.25 V - 465 Ohm

Board: 2 copper layers, 230.0 x 235.0 mm, 175 parts (10 on the bottom side), 76 nets.

## KiCad design hardware/power-distribution-only-fuse/power-distribution-only-fuse.kicad_pcb

Parts:
F1, F2, F3, F4, F5, F6: Fuse; ATO_Fuseholder_3522-2
J1, J2, J3, J5, J6, J7: 12V out; M5_7461383
J4: 12V; M6_7461098

Connections:
+12V: F1.2, F2.2, F3.2, F4.2, F5.2, F6.2, J4.1
/out_1: F1.1, J1.1
/out_2: F2.1, J2.1
/out_3: F3.1, J3.1
/out_4: F4.1, J5.1
/out_5: F5.1, J6.1
/out_6: F6.1, J7.1

Board: 2 copper layers, 13 parts (0 on the bottom side), 7 nets, no tracks yet.

## KiCad design hardware/ideal-diode/ideal-diode.kicad_pcb

Board: 2 copper layers, 70.0 x 50.0 mm, 14 parts (11 on the bottom side), 6 nets.

Parts:
D1, D2: D_TVS; D_SMB
J1: Enable; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J2: M5 Ground; M5_7461383
J3, J4: M5 Output; M5_7461383
Q1, Q10: Q_NMOS_SGD; SQJA72EPT1_GE3
R1: DNP; R_0603_1608Metric
SW1: SW_DIP_x01; SW_CuK_JS202011CQN_DPDT_Straight
U1: LM74700; SOT-23-6
UV1, UV2, UV3: F; C_0603_1608Metric

Connections:
12V_in: D1.1, J1.2, J4.1, Q1.1, Q10.1, R1.1, SW1.1, U1.6, UV1.1, UV2.1
12V_out: D2.1, J3.1, Q1.3, Q10.3, U1.4, UV3.1
GND: D1.2, D2.2, J2.1, U1.2, UV2.2, UV3.2
Gate: Q1.2, Q10.2, U1.5
unnamed: J1.1, R1.2, SW1.2, U1.3
unnamed: U1.1, UV1.2

## KiCad design hardware/flyback-protection/flyback-protection.kicad_pcb

Board: 2 copper layers, 39.0 x 20.0 mm, 3 parts (0 on the bottom side), 2 nets, no tracks yet.

Parts:
D1: D; D_5W_P12.70mm_Horizontal
J1, J2: M5; M5_7461383

Connections:
+12V: D1.1, J1.1
GND: D1.2, J2.1
