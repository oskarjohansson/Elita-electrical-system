# Repository oskarjohansson/Elita-electrical-system (continued)

## KiCad design hardware/led-dimmer/led_dimmer.kicad_pcb

Parts:
C1, C3, C4, C5, C6: C_Small; C_0603_1608Metric
D1, D2: D_Small; D_SOD-123
F1: 5A; ATO_Fuseholder_3522-2
J1: USB_B_Micro; Microusb_105133-0011
J2: Screw_Terminal_01x04; TerminalBlock_Phoenix_MKDS-1,5-4_1x04_P5.00mm_Horizontal
Q3: Q_NMOS_GSD; SOT-23
Q4: Q_PMOS_GDS; TO-252-2
R1, R2: 10k; R_0603_1608Metric
R3, R6, R7, R8, R9: 1k; R_0603_1608Metric
R4: 100k; R_0603_1608Metric
R5: Dummy; R_0402_1005Metric
SW1: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SWD1: SWD_TAGCONNECT; TAG_TC2030-IDC-NL
U1: ATSAMD21G18A-AUT; TQFP-48_7x7mm_P0.5mm
U2: LD1117S33TR_SOT223; SOT-223-3_TabPin2

Connections:
+3V3: C3.2, C6.1, R1.1, R2.2, R4.2, SWD1.1, U1.6 (VDDANA), U1.17 (VDDIO), U1.36 (VDDIO), U1.44 (VDDIN), U2.2 (VO)
+5V: D1.2 (A), J1.1 (VBUS)
+12V: D2.2 (A), F1.1, Q4.3 (S), R6.2, R8.1
A1_BATVOLT: R6.1, R9.2, U1.7 (PB08)
A2: U1.8 (PB09)
A3: U1.9 (PA04)
A4: U1.10 (PA05)
D0: U1.16 (PA11)
D1: U1.15 (PA10)
D2: U1.23 (PA14)
D3_LED: U1.14 (PA09)
D4_PMOS_SWA: U1.13 (PA08)
D5_ENCA: R1.2, SW1.A, U1.24 (PA15)
D8_LED_POWER: Q3.1 (G), R7.1, U1.11 (PA06)
D9_PMOS_SWA: U1.12 (PA07)
D10: U1.27 (PA18)
D11_ENCB: R2.1, SW1.B, U1.25 (PA16)
D13_ENC_SW: C1.1, R3.1, R4.1, U1.26 (PA17)
GND: C1.2, C3.1, C4.1, C5.2, C6.2, J1.5 (GND), J1.6 (Shield), J2.2, J2.3, Q3.2 (S), R5.1, R7.2, R9.1, SW1.C, SW1.S2, SWD1.5, U1.5 (GNDANA), U1.18 (GND), U1.35 (GND), U1.42 (GND), U2.1 (GND)
LED: J2.4, Q4.2 (D)
unnamed: C4.2, U1.43 (VDDCORE)
unnamed: C5.1, D1.1 (K), D2.1 (K), U2.3 (VI)
unnamed: F1.2, J2.1
unnamed: Q3.3 (D), Q4.1 (G), R8.2
unnamed: R3.2, SW1.S1
SCL: U1.32 (PA23)
SDA: U1.31 (PA22)
SWCLK: SWD1.4, U1.45 (PA30)
SWDIO: SWD1.2, U1.46 (PA31)
USB+: J1.3 (D+), U1.34 (PA25)
USB-: J1.2 (D-), U1.33 (PA24)
~RESET: R5.2, SWD1.3, U1.40 (~RESET)

Notes on the sheet:
12V if possible, otherwise 5V

Board: 2 copper layers, 30.0 x 44.0 mm, 25 parts (14 on the bottom side), 20 nets.

## KiCad design hardware/power-distribution/power-distribution.kicad_pcb

Board: 2 copper layers, 90.0 x 70.0 mm, 33 parts (0 on the bottom side), 18 nets.

Parts:
D1, D2, D3, D4: 2V; LED_0603_1608Metric
F1, F2, F3, F4: Fuse; ATO_Fuseholder_3522-2
J1, J2, J3: Parallell; PinHeader_1x02_P2.54mm_Vertical
J4, J6, J7, J8, J9: GND; M5_7461383
J5: 12V; M5_7461383
Q1, Q2, Q3, Q4: Q_PMOS_GDS; TO-252-2
R1, R2, R3, R4: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5, R6, R7, R8: 670R; R_0603_1608Metric
SWITCH_A1: Screw_Terminal_01x0; TerminalBlock_Phoenix_PT-1,5-2-5.0-H_1x02_P5.00mm_Horizontal
SWITCH_B1: Screw_Terminal_01x02; TerminalBlock_Phoenix_PT-1,5-2-5.0-H_1x02_P5.00mm_Horizontal
SWITCH_C1, SWITCH_C2: Screw_Terminal_01x02; TerminalBlock_Phoenix_PT-1,5-2-5.0-H_1x02_P5.00mm_Horizontal

Connections:
+12V: J5.1, Q1.3, Q2.3, Q3.3, Q4.3, R1.1, R2.1, R3.1, R4.1
/AOUT: D1.2, F1.1, J4.1
/BOUT: D2.2, F2.1, J7.1
/COUT: D3.2, F3.1, J8.1
/DOUT: D4.2, F4.1, J9.1
/G1: J1.1, Q1.1, R1.2, SWITCH_A1.1
GND: J6.1, R5.1, R6.1, R7.1, R8.1, SWITCH_A1.2, SWITCH_B1.2, SWITCH_C1.2, SWITCH_C2.2
unnamed: D1.1, R5.2
unnamed: D2.1, R6.2
unnamed: D3.1, R7.2
unnamed: D4.1, R8.2
unnamed: J1.2, J2.1, Q2.1, R2.2, SWITCH_B1.1
unnamed: J2.2, J3.1, Q3.1, R3.2, SWITCH_C1.1
unnamed: J3.2, Q4.1, R4.2, SWITCH_C2.1
SSR-A: F1.2, Q1.2
SSR-B: F2.2, Q2.2
SSR-C: F3.2, Q3.2
SSR-D: F4.2, Q4.2

## KiCad design hardware/battery-protection/battery-protection.kicad_pcb

Parts:
D_LED_IN1: 2V; LED_0603_1608Metric
D_LED_OUT1: 2V; LED_0603_1608Metric
G_PD1: 10k; R_0603_1608Metric
J1: M6 Battery input; M6_7461098
J2: M5 Ground; M5_7461383
J3, J4, J5: M5 Output; M5_7461383
J6: CTRL; TerminalBlock_Phoenix_MKDS-1,5-6_1x06_P5.00mm_Horizontal
Q7, Q8, Q9, Q10, Q11, Q12: Q_NMOS_SGD; SQJA72EPT1_GE3
R_LED_IN1: 680R; R_0603_1608Metric
R_LED_OUT1: 680R; R_0603_1608Metric
SHDN_PD1: 10k; R_0603_1608Metric
U1: LTC4365TS8; SOT-23-8
UV1: 10k; R_0603_1608Metric
UV2: 470R; R_0603_1608Metric
UV3: 100pF; C_0603_1608Metric

Connections:
12V_in: J1.1, J6.1, J6.3, Q7.3 (D), Q8.3 (D), Q9.3 (D), Q10.3 (D), Q11.3 (D), Q12.3 (D), R_LED_IN1.1, U1.1 (Vin), UV1.1
12V_out: J3.1, J4.1, J5.1, J6.5, Q7.1 (S), Q8.1 (S), Q9.1 (S), Q10.1 (S), Q11.1 (S), Q12.1 (S), R_LED_OUT1.1, U1.7 (Vout)
GND: D_LED_IN1.1 (K), D_LED_OUT1.1 (K), G_PD1.1, J2.1, J6.4, J6.6, SHDN_PD1.2, U1.3 (OV), U1.4 (GND), UV2.2, UV3.2
unnamed: D_LED_IN1.2 (A), R_LED_IN1.2
unnamed: D_LED_OUT1.2 (A), R_LED_OUT1.2
unnamed: U1.2 (UV), UV1.2, UV2.1, UV3.1
gate_driver: G_PD1.2, Q7.2 (G), Q8.2 (G), Q9.2 (G), Q10.2 (G), Q11.2 (G), Q12.2 (G), U1.8 (GATE)
~SHDN: J6.2, SHDN_PD1.1, U1.5 (~SHDN)

Notes on the sheet:
Power mosfets
Battery 12V M6 input
Load M5 output
UV Protection
Led indicator
SI7157DP-T1-GE3
0.5 V
Do not use UV

Board: 2 copper layers, 70.0 x 70.0 mm, 22 parts (12 on the bottom side), 8 nets.

## Commit log

2019-11-15 Added 6 relay and screw terminals.
    Added relay
2019-11-15 Added equivalent P-Mosfet
    To avoid all clicking and less current draw.
2019-11-15 Added schematic backup
2019-11-16 Created project library
2019-11-16 Create WireDistresser.kicad_mod
    Just two holes for a small zip tie
2019-11-16 Create XT60PW-F.kicad_mod
    An XT60 pcb mounted
2019-11-16 Create PTSA 1,5 2-3,5-Z.kicad_mod
    An 2-connector from Phoenix
2019-11-16 Create ETB11060B000Z.kicad_mod
    6-pin screw terminal
2019-11-16 Create AOI403.kicad_mod
    P-channel Mosfet with low resistance
2019-11-16 Assign footprint
2019-11-16 Added footprints
2019-11-16 Aligned components
2019-11-16 Added pcb backup to gitignore
2019-11-16 Added mounting holes.
2019-11-16 Added power in sign.
    Added plus and minus sign
2019-11-17 Thicker traces and only +12V filled zones.
    The ground is returning over some other cable, not here.
2019-11-17 Update PCB
2019-11-17 Added 5x20 fuses on PCB
2019-11-17 Removed relay on schematic
2019-11-18 Added serie connector
    To use one switch for multiple MOSFETs. Just a pinheader.
2019-11-18 Finished Rev 1.0
2019-11-18 Moved resistor to create LP-filter from switch.
    Instead of a useless resistor on gate, now in LP-filter from switch.
2019-11-18 Routed updated with LP filter
2019-11-18 Gerberfiles for Rev 1.0
2019-11-21 Changed Mosfet to SMD
    The cheap TH wasn't available at Farnell or RS.
2019-11-21 Rev 1.1
    - SMD Mosfet
    - Thicker traces
2019-11-21 Gerber files rev 1.1
2019-11-21 Changed fuses and added more 3D files.
    Changed to ATO fuses
2019-11-21 Changed to terminal block on input
2019-11-25 Changed into project specific for Elita
2019-11-26 Added a couple of subsystems
2019-11-26 Added current meter
2019-11-26 Added bom for some of the components
2019-11-26 Gerber files
2019-11-26 Updated schematic with Powersplitter added
    Big commit with added powersplitter and updated power distribution board.
2019-11-26 Cache files
2020-01-08 Better copper management
2020-02-19 Moved filled zone to remove shortcurcit
    12V and the mosfets had filled zone together
2020-02-19 Created a simply flyback protection for induction load
2020-02-29 Connect 12V for pullup resistor
    The pullup had lost connection to the 12V plane when changed the leads from fuses to the output.
2020-02-29 Added two ISO documents for installation
2020-03-04 Moved project to hardware
2020-03-04 Moved gerber files
2020-03-06 Changed to only pullup on no LP filter
2020-03-12 Only 4 output
2020-03-12 Assign footprint to all parts and exported .net file
2020-03-12 Deleted old board and renamed ref-name on terminal block
2020-03-12 Routed PCB
2020-03-12 Runned ERC/DRC and exported gerber files
2020-03-12 Moved one trace
2020-03-16 Create a shore power circuit
    A 230V with 30 mA RCD and 16A circuit breaker to protect system.
2020-03-18 Create a MPPT solar circuit for lead acid batteries
2020-03-20 Schematic for complete electrical system
2020-03-20 Added a source selector for 230V
    If in future want a inverter and shore power, these two must newer connect together. A dual circuitbreaker make sure it never happen.
2020-03-21 Added all switched light
2020-03-21 Added ATO fuse
2020-03-21 Addded instrument panel schematic
2020-03-21 Remove old files (been moved before)
2020-03-21 Moved electrical-system folder one up
2020-03-21 Export svg schematic
2020-04-03 Create a LED dimmer project
2020-04-03 Added terminal block, LDO and connected mosfet
2020-04-04 Added power OR-circuit for 5V and 12V
2020-04-04 Added two mosfets for pull both to GND.
2020-04-04 Removed "unnecessary" components
2020-04-08 Changed to just Pmosfet
2020-04-20 Changed to a 4-terminal block
2020-05-19 create usb outlet
2020-05-19 create stereo
2020-05-19 create parameters
2020-05-19 create label
2020-07-04 Changed to 7.62 input pitch and 8 output with 2 and 2
2020-07-04 Placed new components
2020-07-06 Create a battery protection
2020-07-08 Create 3D model of battery protection and cool block
2020-07-08 Finished routing battery protection
2020-07-08 Added aluminum block to batteryprotection
2020-07-08 Changed input connecftor to M5
2020-07-08 Updated the directory description
2020-07-30 Changed to pd for mcu and added pinout for led
2020-07-30 Changed to m5 connector on output
2020-07-30 Order of pcb
2020-08-07 Create power distribution cad
2020-08-07 Initial commit for led dimmer firmware
2020-08-07 Changed to M5 connector for everything
2020-09-10 Changed to M5 connector for flyback
2020-09-14 Changed UV resistor value
2020-09-14 Create two cable manager to 3d print
2020-09-14 Updated wooden panels measurements
2020-09-14 Create an ideal diode
    The ideal diode should be between bulk battery and start battery
2020-09-14 Create an power connector with 3 M5 connector
2020-09-14 Updated the directories
2020-09-18 Updated the readme with more info
2020-09-18 Updated the power splitter
2020-09-18 Ignore any OldVersions folder
2020-09-18 Remove gerber files
2020-09-18 Latest gerber files, zipped
2020-09-18 latest CAD files
2020-09-18 Ideal diode pcb
2020-09-18 Ignore stl files
2020-12-10 Updated ideal diode
2020-12-14 Begging on a big distributions board
2021-01-14 Updated the power distribution schematic and pcb
2021-01-14 Created power distribution with only fuses and connectors
2021-02-03 Power distribution complete first order
    The board is finished and ordered.
    Added TVS diode to protect the board from transients.
2021-02-03 Created enclosure for ideal diode
    The ideal diode that should be between the house battery and start battery. Since only the house battery is charged with solar panels, the solar panel will now also charge the start battery, though i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
2021-02-03 Updated README with some new information
2021-03-04 Changed UV resistor.
    The resistor now will make sure the battery is cut-off at
    20 - 30% SoC.
2021-03-04 Added more resistor calculations.
    Added how to get 11.1 V as UV.
    This is below the voltage before the battery
    is destroyed. An AGM is able to handle
    a couple of these.
2021-05-15 Create inline-dimmer
    A small circuit that uses 555 timer to dim a line.
    Both fuse holder mount or M5 solder pin.
2021-05-16 Added silkscreen and LED
2021-05-17 Created inline dimmer pot holder
    A simple PCB to hold a potentiometer and a screw terminal
